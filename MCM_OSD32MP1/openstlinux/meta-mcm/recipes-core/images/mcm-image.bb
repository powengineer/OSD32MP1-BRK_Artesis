SUMMARY = "MCM image for Octavo OSD32MP1-BRK"
DESCRIPTION = "OpenSTLinux image for six-channel DFSDM acquisition, Cortex-M4 FreeRTOS and USB-Ethernet communication"
LICENSE = "MIT"

require recipes-core/images/octavo-image-weston.bb

IMAGE_BASENAME = "mcm-image"
